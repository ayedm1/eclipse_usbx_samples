<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ux_device_hid_mouse_standalone.ewp</path>
  </project>
  <batchBuild />
</workspace>
